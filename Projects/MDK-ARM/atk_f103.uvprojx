# Keil uVision project atk_f103.uvprojx, settings and files
target uC-OS2 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: atk_f103 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 v6Lto=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\..\User;..\..\Drivers\;..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\CMSIS\Include;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Middlewares;..\..\Middlewares\uC-OS2\uC-CPU\ARM-Cortex-M\ARMv7-M\ARM;..\..\Middlewares\uC-OS2\uC-CPU\Cfg\Template;..\..\Middlewares\uC-OS2\uC-CPU;..\..\Middlewares\uC-OS2\uC-LIB\Cfg\Template;..\..\Middlewares\uC-OS2\uC-LIB;..\..\Middlewares\uC-OS2\uC-OS2\Cfg\Template;..\..\Middlewares\uC-OS2\uC-OS2\Ports\ARM-Cortex-M\ARMv7-M\ARM;..\..\Middlewares\uC-OS2\uC-OS2\Source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group User
    ../../User/: main.c stm32f1xx_it.c uc-os2_demo.c
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/DIR/: DIR.c
    ../../Drivers/BSP/RTC/: rtc.c
    ../../Drivers/BSP/SPI/: spi.c
    ../../Drivers/BSP/TIMER/: gtim.c
    ../../Drivers/BSP/Speed/: speed.c
    ../../Drivers/BSP/IIC/: i2c.c
    ../../Drivers/BSP/RELAY/: relay.c
    ../../Drivers/BSP/OLED/: oled.c
    ../../Drivers/BSP/STEPMOTER/: littlemoter.c
    ../../Drivers/BSP/START/: start.c
    ../../Drivers/BSP/TRANS/: trans.c
    ../../Drivers/BSP/DISTANCE/: distance.c
    ../../../stm32_f103_code_pulse_robot_24/Drivers/BSP/DMA/: dma.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/usart/: usart.c
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_sram.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_spi.c stm32f1xx_ll_sdmmc.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c
  group Middlewares/MALLOC
    ../../Middlewares/MALLOC/: malloc.c
  group Middlewares/uC-OS2/BSP
    ../../Middlewares/uC-OS2/uC-CPU/BSP/Template/: bsp_cpu.c
  group Middlewares/uC-OS2/CPU
    ../../Middlewares/uC-OS2/uC-CPU/ARM-Cortex-M/ARMv7-M/ARM/: cpu_a.asm
    ../../Middlewares/uC-OS2/uC-CPU/ARM-Cortex-M/ARMv7-M/: cpu_c.c
    ../../Middlewares/uC-OS2/uC-CPU/: cpu_core.c
  group Middlewares/uC-OS2/LIB
    ../../Middlewares/uC-OS2/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group Middlewares/uC-OS2/OS2
    ../../Middlewares/uC-OS2/uC-OS2/Cfg/Template/: app_hooks.c
    ../../Middlewares/uC-OS2/uC-OS2/Ports/ARM-Cortex-M/ARMv7-M/ARM/: os_cpu_a.asm os_dbg.c
    ../../Middlewares/uC-OS2/uC-OS2/Ports/ARM-Cortex-M/ARMv7-M/: os_cpu_c.c
    ../../Middlewares/uC-OS2/uC-OS2/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
